v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 570 -780 590 -780 {lab=EN}
N 570 -890 570 -780 {lab=EN}
N 570 -890 590 -890 {lab=EN}
N 630 -890 690 -890 {lab=VDD}
N 690 -960 690 -890 {lab=VDD}
N 630 -960 690 -960 {lab=VDD}
N 630 -960 630 -920 {lab=VDD}
N 630 -780 690 -780 {lab=VSS}
N 690 -780 690 -730 {lab=VSS}
N 630 -730 690 -730 {lab=VSS}
N 630 -750 630 -730 {lab=VSS}
N 630 -860 630 -810 {lab=EN_BAR}
N 760 -780 780 -780 {lab=sel_2}
N 760 -890 760 -780 {lab=sel_2}
N 760 -890 780 -890 {lab=sel_2}
N 820 -890 880 -890 {lab=VDD}
N 880 -960 880 -890 {lab=VDD}
N 820 -960 880 -960 {lab=VDD}
N 820 -960 820 -920 {lab=VDD}
N 820 -780 880 -780 {lab=VSS}
N 880 -780 880 -730 {lab=VSS}
N 820 -730 880 -730 {lab=VSS}
N 820 -750 820 -730 {lab=VSS}
N 820 -860 820 -810 {lab=sel_2_bar}
N 570 -510 590 -510 {lab=sel_1}
N 570 -620 570 -510 {lab=sel_1}
N 570 -620 590 -620 {lab=sel_1}
N 630 -620 690 -620 {lab=VDD}
N 690 -690 690 -620 {lab=VDD}
N 630 -690 690 -690 {lab=VDD}
N 630 -690 630 -650 {lab=VDD}
N 630 -510 690 -510 {lab=VSS}
N 690 -510 690 -460 {lab=VSS}
N 630 -460 690 -460 {lab=VSS}
N 630 -480 630 -460 {lab=VSS}
N 630 -590 630 -540 {lab=sel_1_bar}
N 760 -510 780 -510 {lab=sel_0}
N 760 -620 760 -510 {lab=sel_0}
N 760 -620 780 -620 {lab=sel_0}
N 820 -620 880 -620 {lab=VDD}
N 880 -690 880 -620 {lab=VDD}
N 820 -690 880 -690 {lab=VDD}
N 820 -690 820 -650 {lab=VDD}
N 820 -510 880 -510 {lab=VSS}
N 880 -510 880 -460 {lab=VSS}
N 820 -460 880 -460 {lab=VSS}
N 820 -480 820 -460 {lab=VSS}
N 820 -590 820 -540 {lab=sel_0_bar}
N 1400 -1250 1590 -1250 {lab=VDD}
N 1510 -1480 1510 -1250 {lab=VDD}
N 1510 -1480 1590 -1480 {lab=VDD}
N 1400 -1480 1510 -1480 {lab=VDD}
N 1510 -1370 1590 -1370 {lab=VDD}
N 1400 -1370 1510 -1370 {lab=VDD}
N 1400 -1570 1400 -1510 {lab=#net1}
N 1590 -1570 1590 -1510 {lab=#net1}
N 1400 -1570 1590 -1570 {lab=#net1}
N 1300 -1480 1360 -1480 {lab=sel_2}
N 1300 -1370 1360 -1370 {lab=sel_1_bar}
N 1300 -1250 1360 -1250 {lab=sel_0}
N 1630 -1250 1680 -1250 {lab=sel_0_bar}
N 1630 -1370 1680 -1370 {lab=sel_1}
N 1630 -1480 1680 -1480 {lab=sel_2}
N 1590 -1450 1590 -1400 {lab=#net2}
N 1400 -1450 1400 -1400 {lab=#net3}
N 1400 -1330 1400 -1280 {lab=#net4}
N 1400 -1340 1400 -1330 {lab=#net4}
N 1590 -1340 1590 -1280 {lab=#net5}
N 1340 -1170 1340 -1140 {lab=mixer_4_en}
N 1340 -1170 1600 -1170 {lab=mixer_4_en}
N 1770 -1170 1770 -1140 {lab=mixer_4_en}
N 1400 -1220 1400 -1170 {lab=mixer_4_en}
N 1590 -1220 1590 -1170 {lab=mixer_4_en}
N 1340 -1110 1370 -1110 {lab=VSS}
N 1570 -1110 1600 -1110 {lab=VSS}
N 1770 -1110 1810 -1110 {lab=VSS}
N 1340 -1080 1340 -1040 {lab=#net6}
N 1770 -1080 1770 -1040 {lab=#net6}
N 1570 -1080 1570 -1040 {lab=#net6}
N 1510 -1110 1530 -1110 {lab=sel_1_bar}
N 1270 -1110 1300 -1110 {lab=sel_2}
N 1700 -1110 1730 -1110 {lab=sel_0}
N 1340 -980 1370 -980 {lab=VSS}
N 1570 -980 1600 -980 {lab=VSS}
N 1770 -980 1810 -980 {lab=VSS}
N 1340 -950 1340 -910 {lab=VSS}
N 1340 -910 1600 -910 {lab=VSS}
N 1770 -950 1770 -910 {lab=VSS}
N 1510 -980 1530 -980 {lab=sel_1}
N 1270 -980 1300 -980 {lab=sel_2}
N 1700 -980 1730 -980 {lab=sel_0_bar}
N 1340 -1040 1340 -1010 {lab=#net6}
N 1570 -1040 1570 -1010 {lab=#net6}
N 1770 -1040 1770 -1010 {lab=#net6}
N 1600 -1170 1770 -1170 {lab=mixer_4_en}
N 1600 -910 1770 -910 {lab=VSS}
N 1570 -950 1570 -910 {lab=VSS}
N 1570 -1170 1570 -1140 {lab=mixer_4_en}
N 2190 -1250 2380 -1250 {lab=VDD}
N 2300 -1480 2300 -1250 {lab=VDD}
N 2300 -1480 2380 -1480 {lab=VDD}
N 2190 -1480 2300 -1480 {lab=VDD}
N 2300 -1370 2380 -1370 {lab=VDD}
N 2190 -1370 2300 -1370 {lab=VDD}
N 2190 -1570 2190 -1510 {lab=#net7}
N 2380 -1570 2380 -1510 {lab=#net7}
N 2090 -1480 2150 -1480 {lab=sel_2}
N 2090 -1370 2150 -1370 {lab=sel_1_bar}
N 2090 -1250 2150 -1250 {lab=sel_0}
N 2420 -1250 2470 -1250 {lab=sel_0_bar}
N 2420 -1370 2470 -1370 {lab=sel_1}
N 2420 -1480 2470 -1480 {lab=sel_2}
N 2380 -1450 2380 -1400 {lab=#net8}
N 2190 -1450 2190 -1400 {lab=#net9}
N 2190 -1330 2190 -1280 {lab=#net10}
N 2190 -1340 2190 -1330 {lab=#net10}
N 2380 -1340 2380 -1280 {lab=#net11}
N 2130 -1170 2130 -1140 {lab=mixer_3_en}
N 2130 -1170 2390 -1170 {lab=mixer_3_en}
N 2560 -1170 2560 -1140 {lab=mixer_3_en}
N 2190 -1220 2190 -1170 {lab=mixer_3_en}
N 2380 -1220 2380 -1170 {lab=mixer_3_en}
N 2130 -1110 2160 -1110 {lab=VSS}
N 2360 -1110 2390 -1110 {lab=VSS}
N 2560 -1110 2600 -1110 {lab=VSS}
N 2130 -1080 2130 -1040 {lab=#net12}
N 2560 -1080 2560 -1040 {lab=#net12}
N 2360 -1080 2360 -1040 {lab=#net12}
N 2300 -1110 2320 -1110 {lab=sel_1_bar}
N 2060 -1110 2090 -1110 {lab=sel_2}
N 2490 -1110 2520 -1110 {lab=sel_0}
N 2130 -980 2160 -980 {lab=VSS}
N 2360 -980 2390 -980 {lab=VSS}
N 2560 -980 2600 -980 {lab=VSS}
N 2130 -950 2130 -910 {lab=#net13}
N 2560 -950 2560 -910 {lab=#net13}
N 2300 -980 2320 -980 {lab=sel_1}
N 2060 -980 2090 -980 {lab=sel_2}
N 2490 -980 2520 -980 {lab=sel_0_bar}
N 2130 -1040 2130 -1010 {lab=#net12}
N 2360 -1040 2360 -1010 {lab=#net12}
N 2560 -1040 2560 -1010 {lab=#net12}
N 2390 -1170 2560 -1170 {lab=mixer_3_en}
N 2360 -950 2360 -910 {lab=#net13}
N 2360 -1170 2360 -1140 {lab=mixer_3_en}
N 2630 -1480 2710 -1480 {lab=VDD}
N 2630 -1370 2710 -1370 {lab=VDD}
N 2710 -1570 2710 -1510 {lab=#net7}
N 2750 -1250 2800 -1250 {lab=sel_0}
N 2750 -1370 2800 -1370 {lab=sel_1}
N 2750 -1480 2800 -1480 {lab=sel_2_bar}
N 2710 -1450 2710 -1400 {lab=#net14}
N 2710 -1340 2710 -1280 {lab=#net15}
N 2710 -1220 2710 -1170 {lab=mixer_3_en}
N 2630 -1250 2710 -1250 {lab=VDD}
N 2630 -1370 2630 -1250 {lab=VDD}
N 2630 -1480 2630 -1370 {lab=VDD}
N 2560 -1170 2710 -1170 {lab=mixer_3_en}
N 2130 -840 2160 -840 {lab=VSS}
N 2360 -840 2390 -840 {lab=VSS}
N 2560 -840 2600 -840 {lab=VSS}
N 2130 -810 2130 -770 {lab=VSS}
N 2560 -810 2560 -770 {lab=VSS}
N 2300 -840 2320 -840 {lab=sel_1}
N 2490 -840 2520 -840 {lab=sel_0}
N 2360 -810 2360 -770 {lab=VSS}
N 2130 -910 2130 -870 {lab=#net13}
N 2360 -910 2360 -870 {lab=#net13}
N 2560 -910 2560 -870 {lab=#net13}
N 2130 -1040 2560 -1040 {lab=#net12}
N 2130 -770 2560 -770 {lab=VSS}
N 2050 -840 2090 -840 {lab=sel_2_bar}
N 1500 -1610 1500 -1570 {lab=#net1}
N 1500 -1640 1550 -1640 {lab=VDD}
N 1500 -1740 1500 -1670 {lab=VDD}
N 1420 -1640 1460 -1640 {lab=EN_BAR}
N 1850 -1030 1910 -1030 {lab=VSS}
N 1910 -1170 1910 -1060 {lab=mixer_4_en}
N 1770 -1170 1910 -1170 {lab=mixer_4_en}
N 1910 -1000 1910 -910 {lab=VSS}
N 1770 -910 1910 -910 {lab=VSS}
N 1950 -1030 2000 -1030 {lab=EN_BAR}
N 2650 -1030 2710 -1030 {lab=VSS}
N 2710 -1170 2710 -1060 {lab=mixer_3_en}
N 2710 -1000 2710 -910 {lab=VSS}
N 2750 -1030 2800 -1030 {lab=EN_BAR}
N 2710 -910 2710 -770 {lab=VSS}
N 2560 -770 2710 -770 {lab=VSS}
N 2190 -1570 2710 -1570 {lab=#net7}
N 2500 -1610 2500 -1570 {lab=#net7}
N 2500 -1640 2550 -1640 {lab=VDD}
N 2500 -1740 2500 -1670 {lab=VDD}
N 2420 -1640 2460 -1640 {lab=EN_BAR}
N 3220 -1470 3270 -1470 {lab=VDD}
N 3220 -1570 3220 -1500 {lab=VDD}
N 3140 -1470 3180 -1470 {lab=EN_BAR}
N 3440 -900 3500 -900 {lab=VSS}
N 3500 -1040 3500 -930 {lab=mixer_2_en}
N 3540 -900 3590 -900 {lab=EN_BAR}
N 3120 -1180 3120 -1060 {lab=mixer_2_en}
N 3310 -1180 3310 -1060 {lab=mixer_2_en}
N 3120 -1100 3310 -1100 {lab=mixer_2_en}
N 3310 -1100 3500 -1100 {lab=mixer_2_en}
N 3500 -1100 3500 -1040 {lab=mixer_2_en}
N 3310 -1000 3310 -940 {lab=#net16}
N 3120 -970 3310 -970 {lab=#net16}
N 3120 -1000 3120 -970 {lab=#net16}
N 3120 -970 3120 -940 {lab=#net16}
N 3040 -1030 3080 -1030 {lab=sel_2_bar}
N 3120 -1030 3310 -1030 {lab=VSS}
N 3120 -910 3310 -910 {lab=VSS}
N 3120 -880 3120 -830 {lab=VSS}
N 3120 -830 3310 -830 {lab=VSS}
N 3310 -880 3310 -830 {lab=VSS}
N 3310 -830 3500 -830 {lab=VSS}
N 3500 -870 3500 -830 {lab=VSS}
N 3040 -910 3080 -910 {lab=sel_2_bar}
N 3350 -910 3390 -910 {lab=sel_1_bar}
N 3350 -1030 3400 -1030 {lab=sel_0_bar}
N 3120 -1310 3120 -1240 {lab=#net17}
N 3120 -1400 3120 -1370 {lab=#net18}
N 3120 -1400 3310 -1400 {lab=#net18}
N 3310 -1400 3310 -1370 {lab=#net18}
N 3350 -1340 3390 -1340 {lab=sel_2_bar}
N 3040 -1340 3080 -1340 {lab=sel_2_bar}
N 3040 -1210 3080 -1210 {lab=sel_0_bar}
N 3120 -1210 3310 -1210 {lab=VDD}
N 3120 -1340 3310 -1340 {lab=VDD}
N 3220 -1340 3220 -1210 {lab=VDD}
N 3350 -1210 3380 -1210 {lab=sel_1_bar}
N 3220 -1440 3220 -1400 {lab=#net18}
N 4060 -1470 4110 -1470 {lab=VDD}
N 4060 -1570 4060 -1500 {lab=VDD}
N 3980 -1470 4020 -1470 {lab=EN_BAR}
N 4060 -1440 4060 -1400 {lab=#net19}
N 4240 -920 4300 -920 {lab=VSS}
N 4300 -1060 4300 -950 {lab=mixer_1_divider_1_en}
N 4340 -920 4390 -920 {lab=EN_BAR}
N 4110 -850 4300 -850 {lab=VSS}
N 4300 -890 4300 -850 {lab=VSS}
N 3930 -850 4110 -850 {lab=VSS}
N 3930 -910 3930 -850 {lab=VSS}
N 3930 -940 4120 -940 {lab=VSS}
N 3930 -1010 3930 -970 {lab=#net20}
N 3930 -1010 4120 -1010 {lab=#net20}
N 4120 -1010 4120 -970 {lab=#net20}
N 4040 -1040 4040 -1010 {lab=#net20}
N 4080 -1070 4130 -1070 {lab=sel_2}
N 4060 -1400 4060 -1390 {lab=#net19}
N 4060 -1390 4120 -1390 {lab=#net19}
N 4120 -1390 4120 -1340 {lab=#net19}
N 4160 -1310 4200 -1310 {lab=sel_1}
N 4160 -1210 4200 -1210 {lab=sel_0_bar}
N 4120 -1280 4120 -1250 {lab=#net21}
N 4120 -1250 4120 -1240 {lab=#net21}
N 4120 -1180 4120 -1130 {lab=mixer_1_divider_1_en}
N 3930 -1130 4120 -1130 {lab=mixer_1_divider_1_en}
N 3930 -1230 3930 -1130 {lab=mixer_1_divider_1_en}
N 3930 -1260 4040 -1260 {lab=VDD}
N 4040 -1260 4040 -1210 {lab=VDD}
N 4040 -1210 4120 -1210 {lab=VDD}
N 4040 -1310 4040 -1260 {lab=VDD}
N 4040 -1310 4120 -1310 {lab=VDD}
N 3930 -1390 3930 -1290 {lab=#net19}
N 3930 -1390 4060 -1390 {lab=#net19}
N 3850 -1260 3890 -1260 {lab=sel_2}
N 4040 -1130 4040 -1100 {lab=mixer_1_divider_1_en}
N 4120 -1130 4300 -1130 {lab=mixer_1_divider_1_en}
N 4300 -1130 4300 -1060 {lab=mixer_1_divider_1_en}
N 3860 -940 3890 -940 {lab=sel_0_bar}
N 4120 -910 4120 -850 {lab=VSS}
N 4160 -940 4210 -940 {lab=sel_1}
N 3310 -1310 3310 -1240 {lab=#net22}
N 4010 -1070 4040 -1070 {lab=VSS}
N 4640 -1170 4830 -1170 {lab=VDD}
N 4750 -1400 4750 -1170 {lab=VDD}
N 4750 -1400 4830 -1400 {lab=VDD}
N 4640 -1400 4750 -1400 {lab=VDD}
N 4750 -1290 4830 -1290 {lab=VDD}
N 4640 -1290 4750 -1290 {lab=VDD}
N 4640 -1490 4640 -1430 {lab=#net23}
N 4830 -1490 4830 -1430 {lab=#net23}
N 4640 -1490 4830 -1490 {lab=#net23}
N 4540 -1400 4600 -1400 {lab=sel_2}
N 4540 -1290 4600 -1290 {lab=sel_1}
N 4540 -1170 4600 -1170 {lab=sel_0_bar}
N 4870 -1170 4920 -1170 {lab=sel_0}
N 4870 -1290 4920 -1290 {lab=sel_1}
N 4870 -1400 4920 -1400 {lab=sel_2_bar}
N 4830 -1370 4830 -1320 {lab=#net24}
N 4640 -1370 4640 -1320 {lab=#net25}
N 4640 -1250 4640 -1200 {lab=#net26}
N 4640 -1260 4640 -1250 {lab=#net26}
N 4830 -1260 4830 -1200 {lab=#net27}
N 4580 -1090 4580 -1060 {lab=divider_3_en}
N 4580 -1090 4840 -1090 {lab=divider_3_en}
N 5010 -1090 5010 -1060 {lab=divider_3_en}
N 4640 -1140 4640 -1090 {lab=divider_3_en}
N 4830 -1140 4830 -1090 {lab=divider_3_en}
N 4580 -1030 4610 -1030 {lab=VSS}
N 4810 -1030 4840 -1030 {lab=VSS}
N 5010 -1030 5050 -1030 {lab=VSS}
N 4580 -1000 4580 -960 {lab=#net28}
N 5010 -1000 5010 -960 {lab=#net28}
N 4810 -1000 4810 -960 {lab=#net28}
N 4750 -1030 4770 -1030 {lab=sel_1}
N 4510 -1030 4540 -1030 {lab=sel_2}
N 4940 -1030 4970 -1030 {lab=sel_0_bar}
N 4580 -900 4610 -900 {lab=VSS}
N 4810 -900 4840 -900 {lab=VSS}
N 5010 -900 5050 -900 {lab=VSS}
N 4580 -870 4580 -830 {lab=VSS}
N 4580 -830 4840 -830 {lab=VSS}
N 5010 -870 5010 -830 {lab=VSS}
N 4750 -900 4770 -900 {lab=sel_1}
N 4510 -900 4540 -900 {lab=sel_2_bar}
N 4940 -900 4970 -900 {lab=sel_0}
N 4580 -960 4580 -930 {lab=#net28}
N 4810 -960 4810 -930 {lab=#net28}
N 5010 -960 5010 -930 {lab=#net28}
N 4840 -1090 5010 -1090 {lab=divider_3_en}
N 4840 -830 5010 -830 {lab=VSS}
N 4810 -870 4810 -830 {lab=VSS}
N 4810 -1090 4810 -1060 {lab=divider_3_en}
N 4740 -1530 4740 -1490 {lab=#net23}
N 4740 -1560 4790 -1560 {lab=VDD}
N 4740 -1660 4740 -1590 {lab=VDD}
N 4660 -1560 4700 -1560 {lab=EN_BAR}
N 5090 -950 5150 -950 {lab=VSS}
N 5150 -1090 5150 -980 {lab=divider_3_en}
N 5010 -1090 5150 -1090 {lab=divider_3_en}
N 5150 -920 5150 -830 {lab=VSS}
N 5010 -830 5150 -830 {lab=VSS}
N 5190 -950 5240 -950 {lab=EN_BAR}
N 5750 -1310 5830 -1310 {lab=VDD}
N 5750 -1200 5830 -1200 {lab=VDD}
N 5830 -1400 5830 -1340 {lab=#net29}
N 5870 -1080 5920 -1080 {lab=sel_0}
N 5870 -1200 5920 -1200 {lab=sel_1_bar}
N 5870 -1310 5920 -1310 {lab=sel_2}
N 5830 -1280 5830 -1230 {lab=#net30}
N 5830 -1170 5830 -1110 {lab=#net31}
N 5830 -1050 5830 -1000 {lab=divider_2_en}
N 5830 -1440 5830 -1400 {lab=#net29}
N 5780 -1470 5830 -1470 {lab=VDD}
N 5830 -1570 5830 -1500 {lab=VDD}
N 5870 -1470 5910 -1470 {lab=EN_BAR}
N 5600 -900 5630 -900 {lab=VSS}
N 5830 -900 5860 -900 {lab=VSS}
N 6030 -900 6070 -900 {lab=VSS}
N 5600 -870 5600 -830 {lab=VSS}
N 5600 -830 5860 -830 {lab=VSS}
N 6030 -870 6030 -830 {lab=VSS}
N 5770 -900 5790 -900 {lab=sel_1_bar}
N 5530 -900 5560 -900 {lab=sel_2}
N 5960 -900 5990 -900 {lab=sel_0}
N 5860 -830 6030 -830 {lab=VSS}
N 5830 -870 5830 -830 {lab=VSS}
N 6030 -830 6170 -830 {lab=VSS}
N 6240 -870 6240 -830 {lab=VSS}
N 6170 -830 6180 -830 {lab=VSS}
N 6240 -900 6300 -900 {lab=VSS}
N 5600 -960 5600 -930 {lab=divider_2_en}
N 5600 -960 6180 -960 {lab=divider_2_en}
N 6240 -960 6240 -920 {lab=divider_2_en}
N 6030 -960 6030 -930 {lab=divider_2_en}
N 5830 -960 5830 -930 {lab=divider_2_en}
N 5830 -1000 5830 -970 {lab=divider_2_en}
N 5830 -970 5830 -960 {lab=divider_2_en}
N 5750 -1080 5830 -1080 {lab=VDD}
N 5750 -1470 5750 -1080 {lab=VDD}
N 5750 -1470 5780 -1470 {lab=VDD}
N 6180 -900 6200 -900 {lab=EN_BAR}
N 6180 -960 6240 -960 {lab=divider_2_en}
N 6180 -830 6240 -830 {lab=VSS}
N 4580 -970 4810 -970 {lab=#net28}
N 4810 -970 5010 -970 {lab=#net28}
N 2130 -910 2360 -910 {lab=#net13}
N 2360 -910 2560 -910 {lab=#net13}
N 1340 -1050 1570 -1050 {lab=#net6}
N 1570 -1050 1770 -1050 {lab=#net6}
C {title.sym} 160 -30 0 0 {name=l1 author="Lei Chen"}
C {iopin.sym} 100 -380 0 0 {name=p1 lab=VDD}
C {iopin.sym} 100 -350 0 0 {name=p2 lab=VSS}
C {ipin.sym} 130 -310 0 0 {name=p3 lab=EN}
C {ipin.sym} 130 -280 0 0 {name=p4 lab=sel_2}
C {ipin.sym} 130 -250 0 0 {name=p5 lab=sel_1}
C {ipin.sym} 130 -220 0 0 {name=p6 lab=sel_0}
C {opin.sym} 160 -310 0 0 {name=p7 lab=mixer_1_divider_1_en}
C {opin.sym} 160 -280 0 0 {name=p8 lab=mixer_2_en}
C {opin.sym} 160 -250 0 0 {name=p9 lab=mixer_3_en}
C {opin.sym} 160 -220 0 0 {name=p10 lab=mixer_4_en}
C {opin.sym} 160 -190 0 0 {name=p12 lab=divider_2_en}
C {opin.sym} 160 -160 0 0 {name=p13 lab=divider_3_en}
C {symbols/nfet_03v3.sym} 610 -780 0 0 {name=M1
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 -890 0 0 {name=M2
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 570 -830 0 0 {name=p14 sig_type=std_logic lab=EN}
C {lab_wire.sym} 630 -830 0 1 {name=p15 sig_type=std_logic lab=EN_BAR}
C {lab_wire.sym} 640 -730 0 1 {name=p16 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 640 -960 0 1 {name=p17 sig_type=std_logic lab=VDD}
C {symbols/nfet_03v3.sym} 800 -780 0 0 {name=M3
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 800 -890 0 0 {name=M4
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 760 -830 0 0 {name=p18 sig_type=std_logic lab=sel_2}
C {lab_wire.sym} 820 -830 0 1 {name=p19 sig_type=std_logic lab=sel_2_bar}
C {lab_wire.sym} 830 -730 0 1 {name=p20 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -960 0 1 {name=p21 sig_type=std_logic lab=VDD}
C {symbols/nfet_03v3.sym} 610 -510 0 0 {name=M5
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 -620 0 0 {name=M6
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 570 -560 0 0 {name=p22 sig_type=std_logic lab=sel_1}
C {lab_wire.sym} 630 -560 0 1 {name=p23 sig_type=std_logic lab=sel_1_bar}
C {lab_wire.sym} 640 -460 0 1 {name=p24 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 640 -690 0 1 {name=p25 sig_type=std_logic lab=VDD}
C {symbols/nfet_03v3.sym} 800 -510 0 0 {name=M7
L=0.28u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 800 -620 0 0 {name=M8
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 760 -560 0 0 {name=p26 sig_type=std_logic lab=sel_0}
C {lab_wire.sym} 820 -560 0 1 {name=p27 sig_type=std_logic lab=sel_0_bar}
C {lab_wire.sym} 830 -460 0 1 {name=p28 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 830 -690 0 1 {name=p29 sig_type=std_logic lab=VDD}
C {symbols/pfet_03v3.sym} 1380 -1250 0 0 {name=M9
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1320 -1110 0 0 {name=M10
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1550 -1110 0 0 {name=M11
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1750 -1110 0 0 {name=M12
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1380 -1370 0 0 {name=M13
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1380 -1480 0 0 {name=M14
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1610 -1250 0 1 {name=M15
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1610 -1370 0 1 {name=M16
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1610 -1480 0 1 {name=M17
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1320 -980 0 0 {name=M18
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1550 -980 0 0 {name=M19
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1750 -980 0 0 {name=M20
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1330 -1480 0 0 {name=p11 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 1340 -1370 0 0 {name=p30 sig_type=std_logic lab=sel_1_bar
W=4u}
C {lab_wire.sym} 1340 -1250 0 0 {name=p31 sig_type=std_logic lab=sel_0
W=4u}
C {lab_wire.sym} 1720 -1110 0 0 {name=p32 sig_type=std_logic lab=sel_0
W=2u}
C {lab_wire.sym} 1520 -1110 0 0 {name=p33 sig_type=std_logic lab=sel_1_bar
W=2u}
C {lab_wire.sym} 1290 -1110 0 0 {name=p34 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 1590 -910 0 1 {name=p36 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1580 -980 0 1 {name=p37 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1580 -1110 0 1 {name=p38 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1790 -980 0 1 {name=p39 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1790 -1110 0 1 {name=p40 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1360 -980 0 1 {name=p41 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1360 -1110 0 1 {name=p42 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 1650 -1480 0 1 {name=p43 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 1650 -1370 0 1 {name=p44 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 1640 -1250 0 1 {name=p45 sig_type=std_logic lab=sel_0_bar
W=4u}
C {lab_wire.sym} 1720 -980 0 0 {name=p46 sig_type=std_logic lab=sel_0_bar
W=2u}
C {lab_wire.sym} 1520 -980 0 0 {name=p47 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 1290 -980 0 0 {name=p48 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 1710 -1170 0 0 {name=p49 sig_type=std_logic lab=mixer_4_en}
C {symbols/pfet_03v3.sym} 2170 -1250 0 0 {name=M21
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2110 -1110 0 0 {name=M22
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2340 -1110 0 0 {name=M23
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2540 -1110 0 0 {name=M24
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2170 -1370 0 0 {name=M25
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2170 -1480 0 0 {name=M26
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2400 -1250 0 1 {name=M27
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2400 -1370 0 1 {name=M28
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2400 -1480 0 1 {name=M29
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2110 -980 0 0 {name=M30
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2340 -980 0 0 {name=M31
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2540 -980 0 0 {name=M32
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2120 -1480 0 0 {name=p50 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 2130 -1370 0 0 {name=p51 sig_type=std_logic lab=sel_1_bar
W=4u}
C {lab_wire.sym} 2130 -1250 0 0 {name=p52 sig_type=std_logic lab=sel_0
W=4u}
C {lab_wire.sym} 2510 -1110 0 0 {name=p53 sig_type=std_logic lab=sel_0
W=2u}
C {lab_wire.sym} 2310 -1110 0 0 {name=p54 sig_type=std_logic lab=sel_1_bar
W=2u}
C {lab_wire.sym} 2080 -1110 0 0 {name=p55 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 2370 -980 0 1 {name=p58 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2370 -1110 0 1 {name=p59 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2580 -980 0 1 {name=p60 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2580 -1110 0 1 {name=p61 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2150 -980 0 1 {name=p62 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2150 -1110 0 1 {name=p63 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2440 -1480 0 1 {name=p64 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 2440 -1370 0 1 {name=p65 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 2430 -1250 0 1 {name=p66 sig_type=std_logic lab=sel_0_bar
W=4u}
C {lab_wire.sym} 2510 -980 0 0 {name=p67 sig_type=std_logic lab=sel_0_bar
W=2u}
C {lab_wire.sym} 2310 -980 0 0 {name=p68 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 2080 -980 0 0 {name=p69 sig_type=std_logic lab=sel_2
W=2u}
C {symbols/pfet_03v3.sym} 2730 -1250 0 1 {name=M33
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2730 -1370 0 1 {name=M34
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2730 -1480 0 1 {name=M35
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2110 -840 0 0 {name=M36
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2340 -840 0 0 {name=M37
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2540 -840 0 0 {name=M38
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2370 -840 0 1 {name=p57 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2580 -840 0 1 {name=p73 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2150 -840 0 1 {name=p74 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2280 -770 0 1 {name=p77 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2770 -1480 0 1 {name=p70 sig_type=std_logic lab=sel_2_bar
W=4u}
C {lab_wire.sym} 2760 -1370 0 1 {name=p71 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 2760 -1250 0 1 {name=p72 sig_type=std_logic lab=sel_0
W=4u}
C {lab_wire.sym} 2080 -840 0 0 {name=p75 sig_type=std_logic lab=sel_2_bar
W=2u}
C {lab_wire.sym} 2310 -840 0 0 {name=p76 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 2510 -840 0 0 {name=p78 sig_type=std_logic lab=sel_0
W=2u}
C {lab_wire.sym} 2540 -1170 0 0 {name=p79 sig_type=std_logic lab=mixer_3_en}
C {symbols/nfet_03v3.sym} 1930 -1030 0 1 {name=M39
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1480 -1640 0 0 {name=M40
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 1490 -1480 0 1 {name=p81 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 1520 -1640 0 1 {name=p82 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 1500 -1710 0 1 {name=p83 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1880 -1030 0 0 {name=p84 sig_type=std_logic lab=VSS
W=2u}
C {symbols/nfet_03v3.sym} 2730 -1030 0 1 {name=M41
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2680 -1030 0 0 {name=p86 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 2270 -1480 0 1 {name=p56 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 2630 -1480 0 1 {name=p87 sig_type=std_logic lab=VDD
W=4u}
C {symbols/pfet_03v3.sym} 2480 -1640 0 0 {name=M42
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 2520 -1640 0 1 {name=p89 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 2500 -1710 0 1 {name=p90 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 1970 -1030 0 1 {name=p35 sig_type=std_logic lab=EN_BAR
W=2u}
C {lab_wire.sym} 2770 -1030 0 1 {name=p80 sig_type=std_logic lab=EN_BAR
W=2u}
C {lab_wire.sym} 2440 -1640 0 0 {name=p85 sig_type=std_logic lab=EN_BAR
W=4u}
C {lab_wire.sym} 1440 -1640 0 0 {name=p88 sig_type=std_logic lab=EN_BAR
W=4u}
C {symbols/pfet_03v3.sym} 3200 -1470 0 0 {name=M43
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3240 -1470 0 1 {name=p91 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 3220 -1540 0 1 {name=p92 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 3160 -1470 0 0 {name=p93 sig_type=std_logic lab=EN_BAR
W=4u}
C {symbols/nfet_03v3.sym} 3520 -900 0 1 {name=M44
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3470 -900 0 0 {name=p94 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 3560 -900 0 1 {name=p95 sig_type=std_logic lab=EN_BAR
W=2u}
C {symbols/pfet_03v3.sym} 3100 -1340 0 0 {name=M45
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3100 -1210 0 0 {name=M46
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3330 -1340 0 1 {name=M47
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3330 -1210 0 1 {name=M48
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3100 -1030 0 0 {name=M49
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3330 -1030 0 1 {name=M50
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3100 -910 0 0 {name=M51
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3330 -910 0 1 {name=M52
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3440 -1100 0 0 {name=p104 sig_type=std_logic lab=mixer_2_en}
C {symbols/pfet_03v3.sym} 4040 -1470 0 0 {name=M53
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4080 -1470 0 1 {name=p105 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 4060 -1540 0 1 {name=p106 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 4000 -1470 0 0 {name=p107 sig_type=std_logic lab=EN_BAR
W=4u}
C {symbols/nfet_03v3.sym} 4320 -920 0 1 {name=M54
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4270 -920 0 0 {name=p108 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4360 -920 0 1 {name=p109 sig_type=std_logic lab=EN_BAR
W=2u}
C {symbols/nfet_03v3.sym} 4060 -1070 0 1 {name=M55
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3910 -940 0 0 {name=M56
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4140 -940 0 1 {name=M57
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4140 -1310 0 1 {name=M58
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4140 -1210 0 1 {name=M59
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3910 -1260 0 0 {name=M60
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 3880 -1260 0 0 {name=p110 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 4180 -1310 0 1 {name=p111 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 4040 -1310 0 1 {name=p113 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 3240 -830 0 1 {name=p114 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 3200 -1030 0 1 {name=p115 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 3220 -1340 0 1 {name=p116 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 4020 -940 0 1 {name=p117 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4020 -850 0 1 {name=p118 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4030 -1070 0 0 {name=p119 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4090 -1070 0 1 {name=p120 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 4180 -940 0 1 {name=p122 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 4280 -1130 0 0 {name=p123 sig_type=std_logic lab=mixer_1_divider_1_en}
C {lab_wire.sym} 3210 -910 0 1 {name=p124 sig_type=std_logic lab=VSS
W=2u}
C {symbols/pfet_03v3.sym} 4620 -1170 0 0 {name=M61
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4560 -1030 0 0 {name=M62
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4790 -1030 0 0 {name=M63
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4990 -1030 0 0 {name=M64
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4620 -1290 0 0 {name=M65
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4620 -1400 0 0 {name=M66
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4850 -1170 0 1 {name=M67
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4850 -1290 0 1 {name=M68
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4850 -1400 0 1 {name=M69
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4560 -900 0 0 {name=M70
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4790 -900 0 0 {name=M71
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 4990 -900 0 0 {name=M72
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4830 -830 0 1 {name=p131 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4820 -900 0 1 {name=p132 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4820 -1030 0 1 {name=p133 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 5030 -900 0 1 {name=p134 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 5030 -1030 0 1 {name=p135 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4600 -900 0 1 {name=p136 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4600 -1030 0 1 {name=p137 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 4950 -1090 0 0 {name=p144 sig_type=std_logic lab=divider_3_en}
C {symbols/nfet_03v3.sym} 5170 -950 0 1 {name=M73
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4720 -1560 0 0 {name=M74
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 4730 -1400 0 1 {name=p145 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 4760 -1560 0 1 {name=p146 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 4740 -1630 0 1 {name=p147 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5120 -950 0 0 {name=p148 sig_type=std_logic lab=VSS}
C {lab_wire.sym} 5210 -950 0 1 {name=p149 sig_type=std_logic lab=EN_BAR
W=2u}
C {lab_wire.sym} 4680 -1560 0 0 {name=p150 sig_type=std_logic lab=EN_BAR
W=4u}
C {lab_wire.sym} 4570 -1400 0 0 {name=p125 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 4580 -1290 0 0 {name=p126 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 4580 -1170 0 0 {name=p127 sig_type=std_logic lab=sel_0_bar
W=4u}
C {lab_wire.sym} 4890 -1400 0 1 {name=p128 sig_type=std_logic lab=sel_2_bar
W=4u}
C {lab_wire.sym} 4890 -1290 0 1 {name=p129 sig_type=std_logic lab=sel_1
W=4u}
C {lab_wire.sym} 4880 -1170 0 1 {name=p130 sig_type=std_logic lab=sel_0
W=4u}
C {lab_wire.sym} 4520 -1030 0 0 {name=p138 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 4760 -1030 0 0 {name=p139 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 4960 -1030 0 0 {name=p140 sig_type=std_logic lab=sel_0_bar
W=2u}
C {lab_wire.sym} 4530 -900 0 0 {name=p141 sig_type=std_logic lab=sel_2_bar
W=2u}
C {lab_wire.sym} 4760 -900 0 0 {name=p142 sig_type=std_logic lab=sel_1
W=2u}
C {lab_wire.sym} 4960 -900 0 0 {name=p143 sig_type=std_logic lab=sel_0
W=2u}
C {symbols/pfet_03v3.sym} 5850 -1080 0 1 {name=M75
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5850 -1200 0 1 {name=M76
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5850 -1310 0 1 {name=M77
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 5850 -1470 0 1 {name=M78
L=0.28u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 5810 -1470 0 0 {name=p154 sig_type=std_logic lab=VDD
W=4u}
C {lab_wire.sym} 5830 -1540 0 0 {name=p155 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 5890 -1470 0 1 {name=p156 sig_type=std_logic lab=EN_BAR
W=4u}
C {symbols/nfet_03v3.sym} 6220 -900 0 0 {name=M79
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5580 -900 0 0 {name=M80
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 5810 -900 0 0 {name=M81
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 6010 -900 0 0 {name=M82
L=0.28u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_wire.sym} 5850 -830 0 1 {name=p157 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 5840 -900 0 1 {name=p158 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 6050 -900 0 1 {name=p159 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 5620 -900 0 1 {name=p160 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 6280 -900 0 1 {name=p164 sig_type=std_logic lab=VSS
W=2u}
C {lab_wire.sym} 6190 -900 0 0 {name=p165 sig_type=std_logic lab=EN_BAR}
C {lab_wire.sym} 5540 -900 0 0 {name=p151 sig_type=std_logic lab=sel_2
W=2u}
C {lab_wire.sym} 5780 -900 0 0 {name=p152 sig_type=std_logic lab=sel_1_bar
W=2u}
C {lab_wire.sym} 5980 -900 0 0 {name=p153 sig_type=std_logic lab=sel_0
W=2u}
C {lab_wire.sym} 5900 -1080 0 1 {name=p161 sig_type=std_logic lab=sel_0
W=4u}
C {lab_wire.sym} 5890 -1200 0 1 {name=p162 sig_type=std_logic lab=sel_1_bar
W=4u}
C {lab_wire.sym} 5880 -1310 0 1 {name=p163 sig_type=std_logic lab=sel_2
W=4u}
C {lab_wire.sym} 5970 -960 0 0 {name=p166 sig_type=std_logic lab=divider_2_en
W=2u}
C {lab_wire.sym} 3070 -1030 0 0 {name=p100 sig_type=std_logic lab=sel_2}
C {lab_wire.sym} 3070 -910 0 0 {name=p103 sig_type=std_logic lab=sel_0}
C {lab_wire.sym} 3060 -1210 0 0 {name=p96 sig_type=std_logic lab=sel_0}
C {lab_wire.sym} 3060 -1340 0 0 {name=p97 sig_type=std_logic lab=sel_2}
C {lab_wire.sym} 3370 -1210 0 1 {name=p98 sig_type=std_logic lab=sel_1}
C {lab_wire.sym} 3370 -1340 0 1 {name=p99 sig_type=std_logic lab=sel_2}
C {lab_wire.sym} 3370 -1030 0 1 {name=p101 sig_type=std_logic lab=sel_2}
C {lab_wire.sym} 3360 -910 0 1 {name=p102 sig_type=std_logic lab=sel_1}
C {lab_wire.sym} 4180 -1210 0 1 {name=p112 sig_type=std_logic lab=sel_0}
C {lab_wire.sym} 3880 -940 0 0 {name=p121 sig_type=std_logic lab=sel_0}
